Commit message: 优化网络模型，采用新策略，现在可以任意位置启摆

File: assets/urdf/acrobot.urdf (robot description, URDF)
Before this commit: robot acrobot, 3 links, 2 joints
Joints:
- joint shoulder_joint: limit (none) -> lower=-6.2831853 upper=6.2831853 effort=1.0 velocity=50.0; type continuous -> revolute
